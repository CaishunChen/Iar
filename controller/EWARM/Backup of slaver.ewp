# IAR project Backup of slaver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; xVECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\; ..\\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32F4xx_StdPeriph_Driver\src; ..\User\Application\inc; ..\User\Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: slaver.hex
  ILINK.IlinkOutputFile: slaver.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User/Application
    ../User/Application/: AHRS_EKF.c attitude_control.c control.c data_process.c main.c stabilize_control.c stm32f4xx_it.c
  group User/Driver
    ../User/Driver/source/: ahrs.c delay_init.c IO_Toggle.c myspi.c pwm.c ringbuffer.c SysTick.c time_init.c uart_init.c
    ../User/Driver/inc/: structural.h

# IAR project Backup (2) of slaver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; xVECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\; ..\\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32F4xx_StdPeriph_Driver\src; ..\Libraries\STM32F4xx_StdPeriph_Driver\sys; ..\User\Application\inc; ..\User\Driver\inc; ..\User\Driver\CANAP; ..\User\Driver\CANAPDECODE; ..\User\Driver\sys; ..\User\Driver\source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: slaver.bin
  ILINK.IlinkOutputFile: slaver.out
  ILINK.IlinkIcfFile: slaver.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User/Application
    ../User/Application/: AD7766.c AHRS_EKF.c altitude.c attitude_control.c Auto_Takeoff_Land.c Communication_receive.c Communication_transmit.c control.c Cumulative_FlightTime.c Cumulative_SparyArea.c data_process.c EKF_GPS.c Facility_health_check.c File_Update.c filter.c Head_Redef.c Health_Check_To_TakeOff.c Land_detector.c Library_of_CommonlyUsedFunction.c mag_static_calibration.c main.c modecontroller_selection.c motor.c normal_control.c Observer_Z.c onekey_homing.c Parameter_Setting_Flight_Limitation.c Parameter_Setting_Frametype_Selection.c Parameter_Setting_PropRange_Calibration.c Parameter_Setting_PropSwitch_Setting.c Parameter_Setting_Saveddata_Selection.c Photo.c PID_Parameter.c PIXSensorCombined.c Plant_Protect_Waypoint.c Postion_To_Attitude_control.c Prop_Adaptive_Calibration.c prop_control_mode_update.c Record_GroudStation_WayPoint.c RTK_FDR_Adj.c Safe_Check.c sensor_static_calibration.c stabilize_control.c stm32f4xx_it.c system_state.c TF01.c transmit_date_chose.c Wireless_Send.c
    ../User/Driver/source/: Xbee.c
  group User/Driver
    ../User/Driver/source/: BNO055.c camsbus.c config_init.c DecodeData.c delay_init.c Dev_info.c GPS_Combine_Yaw.c ICM2060x.c imu.c IO_Toggle.c LevelSensor.c Master_i2c.c MS5611.c myspi.c pwm.c Radar_Combine_Alt.c RGB.c ringbuffer.c RTK_Novatel_gps.c sbus.c spi.c SysTick.c time_init.c uart_init.c Voltage_Test.c w25qxx.c
    ../User/Driver/CANAP/: Can_RGB_Command_Generate.c canAP.c
    ../User/Driver/CANAPDECODE/: canAPDecode.c
    ../User/Application/: SRF02.c
    ../User/Driver/sys/: sys.c

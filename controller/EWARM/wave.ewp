# IAR project wave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; xVECT_TAB_SRAM; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\DSP_Lib\Source\TransformFunctions; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32F4xx_StdPeriph_Driver\src; ..\Libraries\STM32F4xx_StdPeriph_Driver\sys; ..\User\Application\inc; ..\User\Driver\inc; ..\User\Driver\sys; ..\User\Driver\source; ..\FATFS\inc; ..\DSP_LIB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wave.bin
  ILINK.IlinkOutputFile: wave.out
  ILINK.IlinkIcfFile: wave.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c ffconf.h
    ../FATFS/src/option/: syscall.c unicode.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User/Application
    ../User/Application/: AHRS_EKF.c Calculate_Wave.c Communication.c Communication_OriData.c filter.c GPS.c IMU_Update.c main.c Safe_Check.c sdfatfs.c Senser_calibration.c stm32f4xx_it.c
  group User/Driver
    ../User/Driver/source/: adconvert.c BNO055.c delay_init.c eeprom.c ICM2060x.c Library_Filter.c malloc.c Master_i2c.c ringbuffer.c RX8010.c sdio_sdcard.c SysTick.c time_init.c uart_init.c
    ../User/Driver/sys/: sys.c
